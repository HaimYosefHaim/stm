# IAR project AI.ewp, settings and files
configuration AI (ARM, debug)
  General.OGChipSelectEditMenu: STM32U585AI ST STM32U585AI
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 6
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32U585xx
  ICCARM.CCIncludePath2: ../Core/Inc; ../Middlewares/ST/AI/Inc; ../X-CUBE-AI/App; ../Drivers/STM32U5xx_HAL_Driver/Inc; ../Drivers/STM32U5xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32U5xx/Include; ../Drivers/CMSIS/Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: AI.hex
  ILINK.IlinkOutputFile: AI.out
  ILINK.IlinkIcfFile: stm32u585xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32u585xx.s
  group Application/User/X-CUBE-AI/App
    ../X-CUBE-AI/App/: network.c network_data.c network_data_params.c
  group Application/User/Core
    ../Core/Src/: main.c stm32u5xx_it.c stm32u5xx_hal_msp.c
  group Doc
    ../X-CUBE-AI/App/: network_generate_report.txt
  group Drivers/STM32U5xx_HAL_Driver
    ../Drivers/STM32U5xx_HAL_Driver/Src/: stm32u5xx_hal_cortex.c stm32u5xx_hal_crc.c stm32u5xx_hal_crc_ex.c stm32u5xx_hal.c stm32u5xx_hal_i2c.c stm32u5xx_hal_i2c_ex.c stm32u5xx_hal_rcc.c stm32u5xx_hal_rcc_ex.c stm32u5xx_hal_flash.c stm32u5xx_hal_flash_ex.c stm32u5xx_hal_gpio.c stm32u5xx_hal_dma.c stm32u5xx_hal_dma_ex.c stm32u5xx_hal_exti.c stm32u5xx_hal_pwr.c stm32u5xx_hal_pwr_ex.c stm32u5xx_hal_gtzc.c stm32u5xx_hal_icache.c stm32u5xx_hal_tim.c stm32u5xx_hal_tim_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32u5xx.c
  group Lib
    ../Middlewares/ST/AI/Lib/: NetworkRuntime810_CM33_IAR.a
